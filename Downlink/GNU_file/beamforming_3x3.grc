<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>beamforming_test</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>bw</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>125e3</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>bw</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>frequency</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>frequency</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value>rx_gain</value></param>
<param><key>max</key><value>89</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>90</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>bw*2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value>tx_gain</value></param>
<param><key>max</key><value>89</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>90</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_zf_rx2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/kevin/Ruonan_WorkSpace/20240405-RSS-CE-Experiment/Experiment_Sec4_Design/RAWDATA/USRP_RSS/USRP_RSS_TEST.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_ctrl_tx1</value></param>
<param><key>file</key><value>/home/kevin/Ruonan_WorkSpace/20240405-RSS-CE-Experiment/Experiment_Sec4_Design/RAWDATA/LoRa_CtrlPKT/Tx_packet/3x3 Tx/RewriteSourceA2L.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_ctrl_tx1_0</value></param>
<param><key>file</key><value>/home/kevin/Ruonan_WorkSpace/20240405-RSS-CE-Experiment/Experiment_Sec4_Design/RAWDATA/LoRa_CtrlPKT/Tx_packet/3x3 Tx/Beamforming_1to9Tx3.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_ctrl_tx1_0_0</value></param>
<param><key>file</key><value>/home/kevin/Ruonan_WorkSpace/20240405-RSS-CE-Experiment/Experiment_Sec4_Design/RAWDATA/LoRa_CtrlPKT/Tx_packet/3x3 Tx/Beamforming_1to9Tx1.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_ctrl_tx1_0_1</value></param>
<param><key>file</key><value>/home/kevin/Ruonan_WorkSpace/20240405-RSS-CE-Experiment/Experiment_Sec4_Design/RAWDATA/LoRa_CtrlPKT/Tx_packet/3x3 Tx/Beamforming_1to9Tx2.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_ctrl_tx1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/kevin/Ruonan_WorkSpace/20240405-RSS-CE-Experiment/Experiment_Sec4_Design/RAWDATA/LoRa_CtrlPKT/input/RewriteSource1to9.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_ctrl_tx1_1_0</value></param>
<param><key>file</key><value>/home/kevin/Ruonan_WorkSpace/20240405-RSS-CE-Experiment/Experiment_Sec4_Design/RAWDATA/LoRa_CtrlPKT/Tx_packet/3x3 Tx/Beamforming__HelloWorldTx1.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_ce_tx1</value></param>
<param><key>phase_inc</key><value>0</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_ce_tx1_0</value></param>
<param><key>phase_inc</key><value>0</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_ce_tx1_0_0</value></param>
<param><key>phase_inc</key><value>0</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_ce_tx1_0_1</value></param>
<param><key>phase_inc</key><value>0</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_ce_tx1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>phase_inc</key><value>0</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_ce_tx1_1_0</value></param>
<param><key>phase_inc</key><value>0</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_zf_rx1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>phase_inc</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Setting sample rate to the highest expected bandwidth enables the bandwidth to be changed on the fly via the resampler.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>Resample to the desired bandwidth.</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_ctrl_tx1</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>samp_rate/bw</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_ctrl_tx1_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>samp_rate/bw</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_ctrl_tx1_0_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>samp_rate/bw</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_ctrl_tx1_0_1</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>samp_rate/bw</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_ctrl_tx1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>samp_rate/bw</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_ctrl_tx1_1_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>samp_rate/bw</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_zf_rx1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>bw/samp_rate</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_zf_tx</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.10.4"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_zf_tx_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>bw1</key><value>bw</value></param>
<param><key>center_freq1</key><value>frequency</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>tx_gain</value></param>
<param><key>ant2</key><value>TX/RX</value></param>
<param><key>bw2</key><value>bw</value></param>
<param><key>center_freq2</key><value>frequency</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>tx_gain</value></param>
<param><key>ant3</key><value>TX/RX</value></param>
<param><key>bw3</key><value>bw</value></param>
<param><key>center_freq3</key><value>frequency</value></param>
<param><key>norm_gain3</key><value>False</value></param>
<param><key>gain3</key><value>7</value></param>
<param><key>ant4</key><value>TX/RX</value></param>
<param><key>bw4</key><value>bw</value></param>
<param><key>center_freq4</key><value>frequency</value></param>
<param><key>norm_gain4</key><value>False</value></param>
<param><key>gain4</key><value>2</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr0= 192.168.10.6,addr1=192.168.10.2,addr2=192.168.10.5,addr3=192.168.10.4,addr4=192.168.10.7"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>clock_source1</key><value>external</value></param>
<param><key>time_source1</key><value>external</value></param>
<param><key>clock_source2</key><value>external</value></param>
<param><key>time_source2</key><value>external</value></param>
<param><key>clock_source3</key><value>external</value></param>
<param><key>time_source3</key><value>external</value></param>
<param><key>clock_source4</key><value>external</value></param>
<param><key>time_source4</key><value>external</value></param>
<param><key>nchan</key><value>5</value></param>
<param><key>num_mboards</key><value>5</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_zf_tx_1</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.10.6"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_zf_rx</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.10.6"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<connection><source_block_id>blocks_file_source_ctrl_tx1</source_block_id><sink_block_id>blocks_rotator_ce_tx1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_ctrl_tx1_0</source_block_id><sink_block_id>blocks_rotator_ce_tx1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_ctrl_tx1_0_0</source_block_id><sink_block_id>blocks_rotator_ce_tx1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_ctrl_tx1_0_1</source_block_id><sink_block_id>blocks_rotator_ce_tx1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_ctrl_tx1_1</source_block_id><sink_block_id>blocks_rotator_ce_tx1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_ctrl_tx1_1_0</source_block_id><sink_block_id>blocks_rotator_ce_tx1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_ce_tx1</source_block_id><sink_block_id>pfb_arb_resampler_ctrl_tx1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_ce_tx1_0</source_block_id><sink_block_id>pfb_arb_resampler_ctrl_tx1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_ce_tx1_0_0</source_block_id><sink_block_id>pfb_arb_resampler_ctrl_tx1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_ce_tx1_0_1</source_block_id><sink_block_id>pfb_arb_resampler_ctrl_tx1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_ce_tx1_1</source_block_id><sink_block_id>pfb_arb_resampler_ctrl_tx1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_ce_tx1_1_0</source_block_id><sink_block_id>pfb_arb_resampler_ctrl_tx1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_zf_rx1</source_block_id><sink_block_id>pfb_arb_resampler_zf_rx1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_ctrl_tx1</source_block_id><sink_block_id>uhd_usrp_sink_zf_tx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_ctrl_tx1</source_block_id><sink_block_id>uhd_usrp_sink_zf_tx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_ctrl_tx1_0</source_block_id><sink_block_id>uhd_usrp_sink_zf_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_ctrl_tx1_0_0</source_block_id><sink_block_id>uhd_usrp_sink_zf_tx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_ctrl_tx1_0_1</source_block_id><sink_block_id>uhd_usrp_sink_zf_tx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_ctrl_tx1_1</source_block_id><sink_block_id>uhd_usrp_sink_zf_tx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_ctrl_tx1_1_0</source_block_id><sink_block_id>uhd_usrp_sink_zf_tx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_zf_rx</source_block_id><sink_block_id>blocks_rotator_zf_rx1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
